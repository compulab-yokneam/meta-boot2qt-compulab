RDEPENDS:${PN}:remove = "qtdoc-examples"

